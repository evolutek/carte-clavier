# Repository evolutek/carte-clavier

## KiCad design V1/Carte Clavier V1.kicad_pcb

Parts:
C1: 100nF; C_0603_1608Metric
C2: 4.7uF; C_0603_1608Metric
D1, D2, D3, D4: RED; LED_0805_2012Metric
D5: GREEN; LED_0805_2012Metric
D6: YELLOW; LED_0805_2012Metric
D7: LED_Dual_AACC; PLCC-4
J1: MotherBoard; 690367281076
J2: Conn_01x03_Male; B03B-PASK
J3, J4: Conn_01x02_Male; B02B-PASK
Q1: Q_PMOS_GSD; SOT-23
R1, R8, R9, R10: 68; R_0603_1608Metric
R2, R3: 10K; R_0603_1608Metric
R5: 820; R_0603_1608Metric
R6: 510; R_0603_1608Metric
R7: 150; R_0603_1608Metric
R11, R12: 100; R_0603_1608Metric
S1: WS-TATL_Switch_12x12; 440YS67082622

Connections:
+3V3: C1.1, D4.2 (A), J1.4, J2.1, R1.2, R3.1
+5V: D3.2 (A), J1.2
+12V: C2.1, D2.2 (A), J1.3, J3.1, J4.1
+BATT: D1.2 (A), J1.1
/BAU: D6.2 (A), J1.8
/LGRE: D7.2 (A2), J1.9
/LRED: D7.1 (A1), J1.7
/TIR: D5.2 (A), J1.6, J2.2
/~RST: J1.10, R2.1, R3.2, S1.B
GND: C1.2, C2.2, J1.5, J2.3, J3.2, J4.2, Q1.3 (D), R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, S1.2, S1.A
unnamed: D1.1 (K), R5.1
unnamed: D2.1 (K), R6.1
unnamed: D3.1 (K), R7.1
unnamed: D4.1 (K), R8.1
unnamed: D5.1 (K), R9.1
unnamed: D6.1 (K), R10.1
unnamed: D7.3 (K1), R12.1
unnamed: D7.4 (K2), R11.1
unnamed: Q1.1 (G), R2.2
unnamed: Q1.2 (S), R1.1, S1.1

Notes on the sheet:
Connector Motherboard
Reset Button
Connector Tirette
Status LEDs
Connectors Fans

Board: 2 copper layers, 35.0 x 28.0 mm, 26 parts (17 on the bottom side), 20 nets.

## Commit log

2020-12-26 First schematic
2020-12-28 Fixed schematic
2020-12-29 Add fans + Started pcb
2020-12-30 First attempt: not good
2020-12-31 V1 more or less done
2020-12-31 Add V1.0 Release
2021-01-09 Fixed button led intensity
2021-01-12 PDFs
2021-01-24 Update the 3D model of the board
2021-01-31 bom, pdf
2021-02-28 Fixed bicolor led
